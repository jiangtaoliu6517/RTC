# Keil uVision project RTC.uvproj, settings and files
target RTC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTC +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\GD\GD32F1x0;..\..\..\Libraries\GD32F1x0_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\GD\GD32F1x0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: date.c main.c stm32f0xx_it.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/GD/GD32F1x0/: system_stm32f0xx.c
  group StdPeriph_Driver
    ../../../Libraries/GD32F1x0_StdPeriph_Driver/src/: DAC.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Startup
    ../../../Libraries/CMSIS/CM3/DeviceSupport/GD/GD32F1x0/: startup_stm32f0xx.s
